# Keil uVision project coremark.uvprojx, settings and files
target coremark (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: coremark
  AfterMake: fromelf --bin --output bin\coremark.bin bin\coremark.axf
  AfterMake: fromelf -cedrst --output bin\coremark.txt bin\coremark.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA COREMARK AM_PART_APOLLO2 keil
  c include: ../../../../../mcu/apollo2;../../../../../devices;../src;../../../../../utils;../../../bsp;../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\coremark.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_time.c core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
