# Keil uVision project SZC_motion_energy_measurement.uvprojx, settings and files
target SZC_motion_energy_measurement (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SZC_motion_energy_measurement
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil
  c include: ../inc;..\..\..\SDK\AmbiqSuite-Rel2.2.0\boards\apollo2_blue_evb\bsp;..\..\..\SDK\AmbiqSuite-Rel2.2.0\boards\apollo2_blue_evb\examples\coremark\src;../../../SDK/AmbiqSuite-Rel2.2.0/devices;../../../SDK/AmbiqSuite-Rel2.2.0/mcu/apollo2;..\..\..\SDK/AmbiqSuite-Rel2.2.0\mcu\apollo2\hal;../../../SDK/AmbiqSuite-Rel2.2.0/utils;..\..\..\SDK\NNoM\inc;..\..\..\SDK\NNoM\port;..\..\..\SDK\NNoM\inc\layers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group src
    ../src/: main.c
  group devices
    ../../../SDK/AmbiqSuite-Rel2.2.0/devices/: am_devices_led.c am_devices_button.c
  group utils
    ../../../SDK/AmbiqSuite-Rel2.2.0/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../SDK/AmbiqSuite-Rel2.2.0/boards/apollo2_blue_evb/bsp/keil/bin/: libam_bsp.lib
    ../../../SDK/AmbiqSuite-Rel2.2.0/mcu/apollo2/hal/keil/bin/: libam_hal.lib
  group NNoM
    ../../../SDK/NNoM/src/backends/: nnom_local.c nnom_local_q15.c
    ../../../SDK/NNoM/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ../../../SDK/NNoM/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group coremark
    ../../../SDK/AmbiqSuite-Rel2.2.0/boards/apollo2_blue_evb/examples/coremark/src/: am_time.c core_portme.c
  group hal
    ../../../SDK/AmbiqSuite-Rel2.2.0/mcu/apollo2/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_ttp.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:NN Lib 3.0.0
